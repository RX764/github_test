## ANDROID/bingfa/yuanzicaozuo/Kconfig
```kconfig
config YUANZICAOZUO
	bool "yuanzcaozuo load driver test"
        default y
	help 
	this is a test!!
```
